# Repository hpmicro/hpm_apps (continued)

## KiCad design apps/rdc/hardware/hardware_project/RS.kicad_pcb

Parts:
C12, C13: 15pF; C_0603_1608Metric
C14, C15, C18, C19, C20, C21: 1uF,50V; C_0603_1608Metric
C16, C17: 1000pF; C_0603_1608Metric
Q10, Q11: DTC143ZCAT116; SOT-23-3_L2.9-W1.4-P1.90-LS2.4-TR
R31, R32: 10; R_0603_1608Metric
R33, R34, R35, R36: 10K; R_0603_1608Metric
R37, R38, R39, R40: 6.8K; R_0603_1608Metric
R41, R42, R47, R49, R51: 100K; R_0603_1608Metric
R43, R44, R45, R46: 0R/NC; R_0603_1608Metric
R48, R50: 62K; R_0603_1608Metric
R52, R53: 3.3K; R_0603_1608Metric
U2: TLV2171IDR; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL
U3, U4: TLV431BFTA; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
U5, U6: CD4053BPWRG3; TSSOP-16_L5.0-W4.4-P0.65-LS6.4-BL

Connections:
/Main_Entry /CONN/CTRL: Q11.2 (B); also elsewhere on the board
/Main_Entry /CONN/INH: Q10.2 (B); also elsewhere on the board
/Main_Entry /CONN/OCOS: C13.1, R32.2; also elsewhere on the board
/Main_Entry /CONN/OSIN: C12.1, R31.2; also elsewhere on the board
/Main_Entry /FeedBack/COS+: C15.2, R46.1, R50.1, U6.15 (OUT/INBXORBY); also elsewhere on the board
/Main_Entry /FeedBack/COS-: C15.1, R45.1, R49.2, U6.14 (OUT/INAXORAY); also elsewhere on the board
/Main_Entry /FeedBack/CTRL_CMOS: Q11.3 (C), R53.2, U5.10 (B), U5.11 (A), U6.10 (B), U6.11 (A)
/Main_Entry /FeedBack/ICOS+: R40.1, R42.2, R46.2, U5.1 (BY), U6.2 (BX)
/Main_Entry /FeedBack/ICOS-: R39.1, R42.1, R45.2, U5.13 (AX), U6.12 (AX)
/Main_Entry /FeedBack/INH_CMOS: Q10.3 (C), R52.2, U5.6 (INH), U6.6 (INH)
/Main_Entry /FeedBack/ISIN+: R38.1, R41.2, R44.2, U5.2 (BX), U6.1 (BY)
/Main_Entry /FeedBack/ISIN-: R37.1, R41.1, R43.2, U5.12 (AX), U6.13 (AX)
/Main_Entry /FeedBack/SIN+: C14.2, R44.1, R48.1, U5.15 (OUT/INBXORBY); also elsewhere on the board
/Main_Entry /FeedBack/SIN-: C14.1, R43.1, R47.2, U5.14 (OUT/INAXORAY); also elsewhere on the board
/Main_Entry /FeedBack/VREF: C16.1, R51.2, U3.1 (REF), U3.2 (CAT)
/Main_Entry /FeedBack/VREF1/2: C16.2, C17.1, R35.2, R36.2, U3.3 (AN), U4.1 (REF), U4.2 (CAT); also elsewhere on the board
GND: C12.2, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, Q10.1 (E), Q11.1 (E), R48.2, R50.2, U2.4 (VSS), U4.3 (AN), U5.3 (CY), U5.4 (OUT/INCXORCY), U5.5 (IN/OUTCX), U5.7 (VEE), U5.8 (VSS), U5.9 (C), U6.3 (CY), U6.4 (OUT/INCXORCY), U6.5 (IN/OUTCX), U6.7 (VEE), U6.8 (VSS), U6.9 (C); also elsewhere on the board
unnamed: R31.1, R33.2, U2.1 (VOUTA)
unnamed: R32.1, R34.2, U2.7 (VOUTB)
unnamed: R33.1, R37.2, U2.2 (VINA-)
unnamed: R34.1, R39.2, U2.6 (VINB-)
unnamed: R35.1, R38.2, U2.3 (VINA+)
unnamed: R36.1, R40.2, U2.5 (VINB+)
VCC: C18.1, C19.1, C20.1, C21.1, R47.1, R49.1, R51.1, R52.1, R53.1, U2.8 (VDD), U5.16 (VDD), U6.16 (VDD); also elsewhere on the board

Notes on the sheet:
SIGNAL RESOLVER FEEDBACK
ANALOG CROSSBAR

Parts:
C5, C6: 0.01uF,50V; C_0603_1608Metric
C7, C8: 18pF; C_0603_1608Metric
C9: 15pF; C_0603_1608Metric
C10: 4700pF; C_0603_1608Metric
C11: 1000pF; C_0603_1608Metric
Q1, Q2, Q5, Q7, Q9: BC817; SOT-23
Q3, Q4, Q6, Q8: BC807; SOT-23
R2, R3, R26, R27: 100K; R_0603_1608Metric
R4, R5, R6, R7, R24, R25, R28, R30: 10K; R_0603_1608Metric
R8, R9: 470K; R_0603_1608Metric
R10, R11, R12, R13: 4.7K; R_0603_1608Metric
R14, R15, R16, R17, R19: 10; R_0603_1608Metric
R18, R20: 3.9K; R_0603_1608Metric
R21: 6.8K; R_0603_1608Metric
R22: 12K; R_0603_1608Metric
R23: 3K; R_0603_1608Metric
R29: 20; R_0603_1608Metric
T16: EXC_N; TPAD_030
T17: EXC_P; TPAD_030
U1: TLV4171IPWR; TSSOP-14_L5.0-W4.5-P0.65-LS6.4-BL

Connections:
/Main_Entry /CONN/OEXC: C9.1, R19.1; also elsewhere on the board
/Main_Entry /CONN/PWM: R18.1; also elsewhere on the board
/Main_Entry /FeedBack/VREF1/2: R25.1; also elsewhere on the board
/Main_Entry /Phase Splitter/EXC+: C7.2, R8.1, R14.1, R15.2, R26.2; also elsewhere on the board
/Main_Entry /Phase Splitter/EXC-: C8.2, R9.1, R16.1, R17.2, R27.2; also elsewhere on the board
/Main_Entry /Phase Splitter/EXC_N: C6.1, Q9.2 (E), R30.2, T16.1
/Main_Entry /Phase Splitter/EXC_P: C5.1, R28.1, R29.2, T17.1
GND: C9.2, C10.2, Q3.3 (C), Q4.3 (C), Q6.3 (C), Q8.3 (C), R5.1, R7.1, R10.1, R11.1, R23.1, R30.1, U1.11 (V-); also elsewhere on the board
unnamed: C5.2, R2.2
unnamed: C6.2, R3.2
unnamed: C7.1, R2.1, R8.2, U1.6 (INB-)
unnamed: C8.1, R3.1, R9.2, U1.9 (INC-)
unnamed: C10.1, R18.2, R20.1, R21.1
unnamed: C11.1, Q9.1 (B), R20.2, U1.1 (OUTA)
unnamed: C11.2, R21.2, U1.2 (INA-)
unnamed: Q1.1 (B), Q3.1 (B), U1.7 (OUTB)
unnamed: Q1.2 (E), Q6.1 (B), R10.2
unnamed: Q2.1 (B), Q4.1 (B), U1.8 (OUTC)
unnamed: Q2.2 (E), Q8.1 (B), R11.2
unnamed: Q3.2 (E), Q5.1 (B), R12.1
unnamed: Q4.2 (E), Q7.1 (B), R13.1
unnamed: Q5.2 (E), R14.2
unnamed: Q6.2 (E), R15.1
unnamed: Q7.2 (E), R16.2
unnamed: Q8.2 (E), R17.1
unnamed: Q9.3 (C), R29.1
unnamed: R4.1, R5.2, U1.5 (INB+)
unnamed: R6.1, R7.2, U1.10 (INC+)
unnamed: R19.2, R24.1, U1.14 (OUTD)
unnamed: R22.1, R23.2, U1.3 (INA+)
unnamed: R24.2, R27.1, U1.13 (IND-)
unnamed: R25.2, R26.1, U1.12 (IND+)
VCC: Q1.3 (C), Q2.3 (C), Q5.3 (C), Q7.3 (C), R4.2, R6.2, R12.2, R13.2, R22.2, R28.2, U1.4 (V+); also elsewhere on the board

Notes on the sheet:
EXCITATION AMPLIFIER SENSING
EXCITATION AMPLIFIER
PWM to SINEWAVE+PHASE SPLITTER

Parts:
C1, C2, C3, C4: 1uF,50V; C_0603_1608Metric
C22, C23: 10uF,50V; C_1206_3216Metric
C24, C25: 102/50V; C_1206_3216Metric
C26, C27: 10uF,35V; CAP-SMD_BD6.3-L6.6-W6.6-LS7.6-FD
D1: LED GREEN; LED
D2: 1_DIODE_ZENER2; DO-214AB
D3: SS24A; SMA-DO-214AC
H1, H2, H3, H4: MountingHole_Pad; HOLE-3.2
J1: 430450600; CONN-TH_43045-0600
J2: HEADER 10X2; IDE-20-A
J3: 5.08-02P
R1: 6.8K; R_0603_1608Metric
R54: 0R; R_0603_1608Metric
R56, R57: 1M; R_1206_3216Metric
T1: VREF1/2; TPAD_030
T2: OCOS; TPAD_030
T3: INH; TPAD_030
T4: CTRL; TPAD_030
T5: COS-; TPAD_030
T6: COS+; TPAD_030
T7: EXC+; TPAD_030
T8: SIN-; TPAD_030
T9: EXC-; TPAD_030
T10: SIN+; TPAD_030
T11: OEXC; TPAD_030
T12: OSIN; TPAD_030
T13: PWM; TPAD_030
T14: VCC; TPAD_030
T15: GND; TPAD_030

Connections:
/Main_Entry /CONN/CTRL: J2.2, T4.1; also elsewhere on the board
/Main_Entry /CONN/INH: J2.4, T3.1; also elsewhere on the board
/Main_Entry /CONN/OCOS: J2.14, T2.1; also elsewhere on the board
/Main_Entry /CONN/OEXC: J2.15, T11.1; also elsewhere on the board
/Main_Entry /CONN/OSIN: J2.13, T12.1; also elsewhere on the board
/Main_Entry /CONN/PWM: J2.7, T13.1; also elsewhere on the board
/Main_Entry /CONN/PWR_IN: D2.2 (K), D3.2 (A), J3.1
/Main_Entry /FeedBack/COS+: J1.5, T6.1; also elsewhere on the board
/Main_Entry /FeedBack/COS-: J1.2, T5.1; also elsewhere on the board
/Main_Entry /FeedBack/SIN+: J1.6, T10.1; also elsewhere on the board
/Main_Entry /FeedBack/SIN-: J1.3, T8.1; also elsewhere on the board
/Main_Entry /FeedBack/VREF1/2: J2.16, T1.1; also elsewhere on the board
/Main_Entry /Phase Splitter/EXC+: J1.4, T7.1; also elsewhere on the board
/Main_Entry /Phase Splitter/EXC-: J1.1, T9.1; also elsewhere on the board
Earth: C24.1, C25.1, H1.1, H2.1, H3.1, H4.1, R56.1, R57.1
GND: C1.2, C2.2, C3.2, C4.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D2.1 (A), J2.17, J3.2, R1.1, R54.2, R56.2, R57.2, T15.1; also elsewhere on the board
unnamed: D1.1 (K), R1.2
unnamed: J2.18, R54.1
VCC: C1.1, C2.1, C3.1, C4.1, C22.1, C23.1, C26.1, C27.1, D1.2 (A), D3.1 (K), T14.1; also elsewhere on the board

Board: 2 copper layers, 145.0 x 90.0 mm, 127 parts (0 on the bottom side), 58 nets.

## KiCad design apps/pmsm_53/hardware/HPM5300_DCServo_CTL_REVB工程/HPM5300_DCServo_CTL_REVB/HPM5300_DCServo_CTL_REVB.kicad_pcb

Notes on the sheet:
20240301
EEPROM
System block diagram
Inverter PWM ADC
Reset KEY
HPM5300_DCServo_CTL_REVB
POWER
HPM5300SKT48QFN
TYPE C CAN
QEO/DIDO
JTAG
Encoder QEI/SSI/BISS-C
Motor UVW
修订历史

Notes on the sheet:
MAIN

Parts:
C1, C2, C3, C4, C8, C9: 0.1uF,16V; C_0402_1005Metric
C5: 10uF,10V; C_0402_1005Metric
C6, C7: 4.7uF,10V; C_0402_1005Metric
J2: Conn_02x04; PinHeader_2x04_P2.54mm_Vertical
J4: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R3, R4: 1K; R_0402_1005Metric
R16, R19: 4.7K; R_0402_1005Metric
R95, R96, R97: 10K; R_0402_1005Metric
SW1: DM-02-V; SW-SMD_DM-02-V
U1: HPM5300QFN48; QFN-48_6x6mm_P0.4mm_EP4.2x4.2mm
U4: AT24C16; SOIC-8

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, J2.3, J4.1, R16.2, R19.2, R96.2, R97.2, SW1.1 (PIN1), SW1.2 (PIN2), U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.34 (VIO_B00), U4.8 (VCC); also elsewhere on the board
/MAIN/CAN_CH340/CAN2RX: U1.18 (PY01/TMR3.CAPT0/URT0.RXD/CAN2.RXD/PWM0.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); also elsewhere on the board
/MAIN/CAN_CH340/CAN2TX: U1.19 (PY00/TMR3.COMP0/URT0.TXD/CAN2.TXD/PWM0.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); also elsewhere on the board
/MAIN/CAN_CH340/RXD: U1.11 (PA01/TMR1.CAPT0/URT0.RXD/CAN0.RXD/PWM0.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); also elsewhere on the board
/MAIN/CAN_CH340/TXD: U1.12 (PA00/TMR1.COMP0/URT0.TXD/CAN0.TXD/PWM0.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); also elsewhere on the board
/MAIN/DRV/ADC0: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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); also elsewhere on the board
/MAIN/DRV/ADC1: U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/PWM1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); also elsewhere on the board
/MAIN/DRV/PWM_0: U1.44 (PA24/TMR2.COMP1/URT6.TXD/I2C2.SCL/SPI1.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); also elsewhere on the board
/MAIN/DRV/PWM_1: U1.43 (PA25/TMR2.CAPT1/URT6.RXD/I2C2.SDA/SPI1.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); also elsewhere on the board
/MAIN/DRV/PWM_4: U1.40 (PA28/URT7.CTS/I2C3.SDA/SPI1.MISO/XPI0.C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); also elsewhere on the board
/MAIN/DRV/PWM_5: U1.39 (PA29/TMR3.COMP3/URT7.DE/URT7.RTS/I2C3.S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); also elsewhere on the board
/MAIN/DRV/PWM_6: U1.38 (PA30/URT7.RXD/SPI1.DAT2/CAN3.RXD/XPI0.C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); also elsewhere on the board
/MAIN/DRV/PWM_7: U1.37 (PA31/TMR2.COMP3/URT7.TXD/SPI1.DAT3/CAN3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); also elsewhere on the board
/MAIN/ENC/QEI0_A/SEI0_DE: U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/PWM1.F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); also elsewhere on the board
/MAIN/ENC/QEI0_B/SEI0_CK: U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
/MAIN/ENC/QEI0_Z/SEI0_TX: U1.21 (PB14/URT3.RXD/SPI2.DAT2/CAN3.RXD/PWM0.F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); also elsewhere on the board
/MAIN/ENC/SEI0_RX: U1.20 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/CAN3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); also elsewhere on the board
/MAIN/MCU/BOOT0: R4.2, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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)
/MAIN/MCU/BOOT1: R3.2, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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)
/MAIN/MCU/GPIO1: J4.3, U1.3 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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)
/MAIN/MCU/GPIO2: J4.4, U1.4 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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)
/MAIN/MCU/JTAG_TCK: J2.7, R95.2, U1.47 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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)
/MAIN/MCU/JTAG_TDI: J2.6, R96.1, U1.48 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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)
/MAIN/MCU/JTAG_TDO: J2.5, U1.1 (PA04/URT1.CTS/SPI0.CS0/CAN1.RXD/PWM0.P0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)
/MAIN/MCU/JTAG_TMS: J2.8, R97.1, U1.46 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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)
/MAIN/MCU/JTAG_TRST: J2.4, U1.2 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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)
/MAIN/MCU/QEO0_A/GPIO3: J4.5, U1.42 (PA26/TMR2.COMP2/URT6.DE/URT6.RTS/SPI1.C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)
/MAIN/MCU/QEO0_B/GPIO4: J4.6, U1.41 (PA27/URT6.CTS/SPI1.SCLK/XPI0.CA_SCLK/PW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)
/MAIN/MCU/SCL2: R16.1, U1.27 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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), U4.6 (SCL)
/MAIN/MCU/SDA2: R19.1, U1.26 (PB09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI2.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), U4.5 (SDA)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.1, C9.2, J2.1, J2.2, J4.2, R95.1, U4.1 (NC), U4.2 (NC), U4.3 (NC), U4.4 (GND), U4.7 (WP); also elsewhere on the board
unnamed: R4.1, SW1.3 (PIN3)
unnamed: R3.1, SW1.4 (PIN4)
VDD_OTPCAP: C7.1, C9.1, U1.10 (VDD_OTPCAP)
VDD_PMCCAP: C6.2, C8.2, U1.17 (VDD_PMCCAP)

Notes on the sheet:
MCU

Notices in the files:
boards/hpm5300evk_stepper/board.h:
Copyright (c) 2023 HPMicro
SPDX-License-Identifier: BSD-3-Clause
