# Repository hpmicro/hpm_apps (continued)

## KiCad design apps/pmsm_53/hardware/HPM5300_DCServo_CTL_REVB工程/HPM5300_DCServo_CTL_REVB/HPM5300_DCServo_CTL_REVB.kicad_pcb (continued)

Parts:
C10, C11, C47, C49, C52: 0.1uF,16V; C_0402_1005Metric
C12: 10nF,50V; C_0603_1608Metric
C13, C14: 47pF,50V; C_0402_1005Metric
C46, C48: 12pF,50V; C_0402_1005Metric
C50: 22uF,10V; C_0603_1608Metric
C51: 4.7uF,10V; C_0402_1005Metric
CN3: X2011WR-03A-N0SN; CONN-TH_X2011WR-3A-N0SN
D1: NUP2105L; SOT-23
D3: SS24; D_SMA
J1: USB_Type-C; TYPE-C-16P
L1: ACT45B-510-2P-TL003; L4532
L5: DLW21SN900SQ2L; L2012
LED3: LED_GREEN; LED_0603
R6, R7: 75Ω_0603; R_0603_1608Metric
R8, R33, R36: 10K; R_0402_1005Metric
R9, R10: 60.4Ω_1206; R_1206_3216Metric
R11, R31: 0Ω_0402; R_0402_1005Metric
R35: 1M; R_0402_1005Metric
R37, R38, R43, R44: 5.1K; R_0402_1005Metric
R39: 1K; R_0402_1005Metric
R40: 2K; R_0402_1005Metric
R41, R42: 33Ω; R_0402_1005Metric
SW2, SW3: 轻触开关4.5mm*4.5mm*4mm; 轻触开关SMD-4P,4.5x4.5mm
U1: HPM5300QFN48; QFN-48_6x6mm_P0.4mm_EP4.2x4.2mm
U2: TJA1042T/3; SOIC-8
U7: PRTR5V0U2X; SOT-143
U8: CH340E; MSOP-10
X1: 24MHz ±10ppm 12pF; 3225

Connections:
+3.3V: C10.1, C51.2, C52.1, R33.1, R43.2, R44.2, SW3.2, U2.5 (VIO), U8.7 (VCC), U8.10 (V3); also elsewhere on the board
+5V: C11.2, D3.1 (K), U2.3 (VCC); also elsewhere on the board
/MAIN/CAN_CH340/CAN2RX: R7.1; also elsewhere on the board
/MAIN/CAN_CH340/CAN2TX: R6.1; also elsewhere on the board
/MAIN/CAN_CH340/CAN2_N: C14.2, CN3.2, D1.2 (K), L1.3, R10.1
/MAIN/CAN_CH340/CAN2_P: C13.1, CN3.1, D1.1 (K), L1.4, R9.2
/MAIN/CAN_CH340/RESETN: C47.1, R33.2, SW2.4, U1.13 (RESETN)
/MAIN/CAN_CH340/RXD: R41.2, R44.1; also elsewhere on the board
/MAIN/CAN_CH340/TXD: R42.2, R43.1; also elsewhere on the board
/MAIN/CAN_CH340/UD+: L5.3, U8.1 (UD+)
/MAIN/CAN_CH340/UD-: L5.2, U8.2 (UD-)
/MAIN/CAN_CH340/VBUS_DEBUG: C50.1, D3.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U7.4 (VCC)
/MAIN/CAN_CH340/WAKEUP: C49.1, R36.2, SW3.4, U1.14 (WAKEUP)
/MAIN/CAN_CH340/_+: J1.A6 (DP1), J1.B6 (DP2), L5.4, U7.2 (I/O1)
/MAIN/CAN_CH340/_-: J1.A7 (DN1), J1.B7 (DN2), L5.1, U7.3 (I/O2)
GND: C10.2, C11.1, C12.2, C13.2, C14.1, C46.2, C47.2, C48.2, C49.2, C50.2, C51.1, C52.2, CN3.3, J1.1 (EP), J1.2 (EP), J1.3 (EP), J1.4 (EP), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), R8.1, R11.2, R31.1, R36.1, R37.1, R38.1, R39.1, SW2.2, U2.2 (GND), U7.1 (GND), U8.3 (GND), X1.2 (GND); also elsewhere on the board
unnamed: C12.1, R9.1, R10.2
unnamed: D1.3 (A), R11.1
unnamed: J1.A5 (CC1), R38.2
unnamed: J1.B5 (CC2), R37.2
unnamed: LED3.2 (A), U8.6 (TNOW)
unnamed: LED3.1 (K), R39.2
unnamed: R31.2, X1.4 (GND)
unnamed: C46.1, R35.2, U1.35 (XTALI), X1.3 (X2)
unnamed: C48.1, R35.1, U1.36 (XTALO), X1.1 (X1)
unnamed: L1.1, U2.7 (CANH)
unnamed: L1.2, U2.6 (CANL)
unnamed: R7.2, U2.4 (RXD)
unnamed: R8.2, U2.8 (STB)
unnamed: R6.2, U2.1 (TXD)
unnamed: R42.1, U8.9 (RXD)
unnamed: R41.1, U8.8 (TXD)
unnamed: R40.2, U8.5 (~CTS)
unnamed: R40.1, U8.4 (~RTS)

Notes on the sheet:
默认焊接无源晶振 兼容有源晶振
CAN/CH340
CAN
USB_CH340
OSC_Domain

Parts:
J6: Conn_02x06; PinHeader_2x06_P2.54mm_Vertical

Connections:
+3.3VA: J6.5; also elsewhere on the board
+5V: J6.1; also elsewhere on the board
/MAIN/DRV/ADC0: J6.2; also elsewhere on the board
/MAIN/DRV/ADC1: J6.11; also elsewhere on the board
/MAIN/DRV/PWM_0: J6.3; also elsewhere on the board
/MAIN/DRV/PWM_1: J6.4; also elsewhere on the board
/MAIN/DRV/PWM_4: J6.7; also elsewhere on the board
/MAIN/DRV/PWM_5: J6.8; also elsewhere on the board
/MAIN/DRV/PWM_6: J6.9; also elsewhere on the board
/MAIN/DRV/PWM_7: J6.10; also elsewhere on the board
GND: J6.12; also elsewhere on the board
GNDA: J6.6; also elsewhere on the board

Notes on the sheet:
DRV

Parts:
C53, C54, C61: 0.1uF,50V; C_0603_1608Metric
C55, C56, C57, C58, C59, C60: 220pF,50V; C_0603_1608Metric
C62: 10uF,16V; C_0603_1608Metric
C90, C91, C92: 220pF,50V; C_0402_1005Metric
D4, D5, D6: NUP2105L; SOT-23
D7, D8, D9: PESD5V2S2UT; SOT-23
FB2: 600Ω@1MHz,0805; R_0805_2012Metric
J3: DDMRH15PFE006; DSUB-TH_15P-P2.29-H-F_DDMRH15PFE006
L6, L7, L8: ACT45B-510-2P-TL003; L4532
R45, R46, R54: 120Ω; R_0805_2012Metric
R47, R48, R49, R50, R55, R87: 10Ω; R_0402_1005Metric
R51, R56, R59, R62, R94, R105: 10K; R_0603_1608Metric
R52, R53, R71, R72, R73, R103, R104: 0Ω_0603; R_0603_1608Metric
R65, R66, R67, R68, R69, R70: 22R，0603; R_0603_1608Metric
U10: SIT3490EESA; SOIC-8
U11: AM26LV32EIDR; SOIC-16
U19: MAX3485EESA+T; SOIC-8

Connections:
+3.3V: C54.1, C61.1, C62.1, R94.2, U11.16 (VCC), U19.8 (VCC); also elsewhere on the board
+5V: C53.1, FB2.2, R51.2, U10.1 (VCC), U11.4 (G); also elsewhere on the board
+5V_QEI: FB2.1, J3.13, R56.1, R59.1, R62.1
/MAIN/ENC/485_N: D6.2 (K), J3.9, L8.4, R54.1
/MAIN/ENC/485_P: D6.1 (K), J3.4, L8.3, R54.2
/MAIN/ENC/AN: C56.2, R66.2, U11.1 (1B)
/MAIN/ENC/AP: C55.1, R65.2, U11.2 (1A)
/MAIN/ENC/BN: C58.2, R68.2, U11.7 (2B)
/MAIN/ENC/BP: C57.1, R67.2, U11.6 (2A)
/MAIN/ENC/CI_+: L6.1, R47.2
/MAIN/ENC/CI_-: L6.2, R48.2
/MAIN/ENC/CLK_N: D5.2 (K), J3.15, L7.4, R46.2
/MAIN/ENC/CLK_P: D5.1 (K), J3.14, L7.3, R46.1
/MAIN/ENC/CO_+: L7.2, R50.2
/MAIN/ENC/CO_-: L7.1, R49.2
/MAIN/ENC/DATA_N: D4.1 (K), J3.10, L6.3, R45.2
/MAIN/ENC/DATA_P: D4.2 (K), J3.5, L6.4, R45.1
/MAIN/ENC/DA_+: L8.2, R87.2
/MAIN/ENC/DA_-: L8.1, R55.2
/MAIN/ENC/QA+: D7.2, J3.1, R56.2, R65.1
/MAIN/ENC/QA-: D7.1, J3.11, R66.1
/MAIN/ENC/QB+: D8.2, J3.2, R59.2, R67.1
/MAIN/ENC/QB-: D8.1, J3.12, R68.1
/MAIN/ENC/QEI0_A/SEI0_DE: C91.1, R71.1, R105.2, U19.2 (~RE), U19.3 (DE); also elsewhere on the board
/MAIN/ENC/QEI0_B/SEI0_CK: C92.1, R53.1, R72.1; also elsewhere on the board
/MAIN/ENC/QEI0_Z/SEI0_TX: C90.1, R73.2, R104.1; also elsewhere on the board
/MAIN/ENC/QZ+: D9.2, J3.7, R62.2, R69.1
/MAIN/ENC/QZ-: D9.1, J3.8, R70.1
/MAIN/ENC/SEI0_RX: R52.1, R103.1; also elsewhere on the board
/MAIN/ENC/ZN: C60.2, R70.2, U11.9 (3B)
/MAIN/ENC/ZP: C59.1, R69.2, U11.10 (3A)
GND: C53.2, C54.2, C55.2, C56.1, C57.2, C58.1, C59.2, C60.1, C61.2, C62.2, C90.2, C91.2, C92.2, D4.3 (A), D5.3 (A), D6.3 (A), D7.3, D8.3, D9.3, J3.3, R105.1, U10.4 (GND), U11.8 (GND), U11.12 (G#), U11.14 (4A), U11.15 (4B), U19.5 (GND); also elsewhere on the board
unnamed: R47.1, U10.8 (A)
unnamed: R48.1, U10.7 (B)
unnamed: R53.2, U10.3 (DI)
unnamed: R51.1, R52.2, U10.2 (RO)
unnamed: R50.1, U10.5 (Y)
unnamed: R49.1, U10.6 (Z)
unnamed: R71.2, U11.3 (1Y)
unnamed: R72.2, U11.5 (2Y)
unnamed: R73.1, U11.11 (3Y)
unnamed: R87.1, U19.6 (A)
unnamed: R55.1, U19.7 (B)
unnamed: R104.2, U19.4 (DI)
unnamed: R94.1, R103.2, U19.1 (RO)
PE: J3.16, J3.17; also elsewhere on the board

Notes on the sheet:
422
QEI
485
ENC

Parts:
C15, C16, C17, C18, C25, C41: 10uF,16V; R_0603_1608Metric
C19, C22, C26, C29, C30, C32, C33, C35, C37, C39, C40, C44: 0.1uF,16V; C_0402_1005Metric
C20: 1uF,16V; R_0603_1608Metric
C23: 1nF,50V; C_0402_1005Metric
C24, C34: 4.7uF,16V; C_0603_1608Metric
C31: 22pF,50V; C_0402_1005Metric
C36, C38: 22uF,10V; C_0603_1608Metric
C70, C71: 10nF,630V,1206; C_1206_3216Metric
FB1: 600Ω@100MHz_1.3A; R_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
L2, L4: 4.7uH-1.24A 156mΩ; L3012
LED2: LED_GREEN; LED_0603
R1: 0Ω_0603; R_0603_1608Metric
R12: 10K; R_0402_1005Metric
R17: 100K; R_0402_1005Metric
R18: 22.1K; R_0402_1005Metric
R23: 100Ω; R_0402_1005Metric
R24: 1K; R_0402_1005Metric
R26: 0Ω_0402; R_0402_1005Metric
R28: 4.7K 0.1%; R_0402_1005Metric
R29: 220Ω 0.5%; R_0402_1005Metric
R30: 3K 0.1%; R_0402_1005Metric
U1: HPM5300QFN48; QFN-48_6x6mm_P0.4mm_EP4.2x4.2mm
U3: SM8082AAAC; SOT-23-5
U5: AZ432ANTR-E1; SOT-23

Connections:
+3.3V: C31.1, C33.1, C36.1, C38.1, L4.2, LED2.2 (A), R17.2; also elsewhere on the board
+3.3VA: C30.1, C34.1, C40.1, C41.1, C44.1, FB1.2, R23.2, R28.2, U1.31 (VREFH), U5.2 (C); also elsewhere on the board
+5V: C15.1, C17.1, C19.1, R12.2, R23.1, U3.4 (IN); also elsewhere on the board
DCDC_LP: L2.2, U1.15 (DCDC_LP)
GND: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C25.2, C29.2, C32.2, C33.2, C35.2, C36.2, C37.2, C38.2, C39.2, C70.1, C71.2, R18.1, R24.1, R26.1, U1.49 (VSS), U3.2 (GND); also elsewhere on the board
GNDA: C24.2, C26.2, C30.2, C34.2, C40.2, C41.2, C44.2, R26.2, R30.1, U1.30 (VREFL), U5.3 (A); also elsewhere on the board
unnamed 70: C16.1, C18.1, C20.1, C22.1, C25.1, L2.1; also elsewhere on the board
unnamed: LED2.1 (K), R24.2
unnamed: R28.1, R29.2
unnamed: C23.1, R12.1, U3.1 (EN)
unnamed: C31.2, R17.1, R18.2, U3.5 (FB)
unnamed: L4.1, U3.3 (LX)
unnamed: R29.1, R30.2, U5.1 (R)
PE: C70.2, C71.1, H1.1, H4.1; also elsewhere on the board
VANA: C24.1, C26.1, FB1.1, U1.32 (VANA)
VDD_SOC: C29.1, C32.1, C35.1, C37.1, C39.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC); also elsewhere on the board

Notes on the sheet:
PWR_Domain
POWER

Board: 4 copper layers, 50.3 x 56.1 mm, 167 parts (79 on the bottom side), 114 nets.

Other parts of the board:
R34: 0Ω_0603; R_0603_1608Metric

Their connections:
unnamed 70: R34.2; also elsewhere on the board
VDD_SOC: R34.1; also elsewhere on the board

## Code that names these connections

File boards/hpm5300evk_stepper/board.h (part):

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
/*PWM define*/
#define BOARD_STEPPER0PWM                     HPM_PWM0
#define BOARD_STEPPER0_A0H_PWM_OUTPIN         (4U)//pwm_VH
#define BOARD_STEPPER0_A0L_PWM_OUTPIN         (5U)//pwm_VL
#define BOARD_STEPPER0_B0H_PWM_OUTPIN         (2U)//PWM_WH
#define BOARD_STEPPER0_B0L_PWM_OUTPIN         (3U)//PWM_WL
#define BOARD_STEPPER0PWM_TRGM                HPM_TRGM0
#define BOARD_STEPPER0APP_PWM_IRQ             IRQn_PWM0
#define BOARD_STEPPER0PWM_CMP_INDEX_A0H         (0U)
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
## Commit log

2024-07-30 hpm apps release v1.6.0
2024-08-02 docs: update doxygen
2024-08-02 cmake: update middleware import
2024-11-07 hpm apps release v1.7.0
2025-02-10 hpm apps release v1.8.0
2025-05-12 hpm apps release v1.9.0
2025-08-11 update(ethercat_master): update to v1.10
2025-08-29 hpm apps release v1.10.0
2025-12-25 hpm apps release v1.10.1
2026-04-03 update: update cherryecat to v2.0.1
2026-06-08 hpm apps release v1.11.0
2026-06-22 hpm apps release v1.11.1; update hpm_monitor
